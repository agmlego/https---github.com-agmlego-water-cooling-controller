# Repository agmlego/https---github.com-agmlego-water-cooling-controller

File README.md:

External Water-Cooling Loop Controller
--------------------------------------

The intent of this project is to monitor and control an external chiller system for a PC water-cooling loop with a liquid-liquid heat exchanger to separate the internal and external loops.

There is a PCIe x1 card inside the PC, tapping into SMBus and +3V3AUX, to monitor the flow, inlet, and outlet temperatures for the internal and external loops, and intercept the front panel power switch to prevent boot or to initiate a shutdown if the loops are not working correctly. The Teensy 3.2 will communicate to the PC, pretending to be a common SMBus device such as those from Winbond or Nuvoton. It also talks with an external board in the chiller over RS232. Onboard WS2811B and an OLED screen show immediate diagnostics. An onboard BME280 lets the Teensy monitor internal case ambient temperature and humidity, to ensure that the chiller does not drop below the local dewpoint to prevent condensation.

The external board listens to RS232 and adjusts the chiller's power state and setpoint. It also reports the local BME280 results and has an onboard OLED screen for system status.

## Internal PCIe Card

| Pin | Type    | Signal | Direction | Purpose                                      |
| --- | ------- | ------ | --------- | -------------------------------------------- |
| 1   | POWER   | GND    |           | Digital ground plane                         |
| 2   | DIGITAL | D0     | INPUT     | Internal loop flow sensor                    |
| 3   | DIGITAL | D1     | INPUT     | External loop flow sensor                    |
| 7   | DIGITAL | D5     | OUTPUT    | Level shifter output enable, active low      |
| 8   | DIGITAL | D6     | INPUT     | PCIe #PERST status                           |
| 9   | DIGITAL | D7     | OUTPUT    | WS2811B data                                 |
| 11  | RS232   | RX     | INPUT     | RS232 receive                                |
| 12  | RS232   | TX     | OUTPUT    | RS232 transmit                               |
| 21  | ANALOG  | A0     | INPUT     | External loop outflow temperature, 10k   NTC |
| 22  | ANALOG  | A1     | INPUT     | External loop inflow temperature, 10k NTC    |
| 23  | ANALOG  | A2     | INPUT     | Internal loop inflow temperature, 10k   NTC  |
| 24  | ANALOG  | A3     | INPUT     | Internal loop outflow temperature, 10k NTC   |
| 25  | I2C     | SDA0   | BIDI      | SMBus I2C data                               |
| 26  | I2C     | SCL0   | BIDI      | SMBus I2C clock                              |
| 29  | DIGITAL | D22    | OUTPUT    | Front panel power switch output              |
| 30  | DIGITAL | D23    | INPUT     | Front panel power switch input               |
| 31  | POWER   | 3V3    |           | 3.3V AUX input                               |
| 32  | POWER   | AGND   |           | Analog ground plane                          |
| 42  | POWER   | 3V3    |           | 3.3V AUX input                               |
| 46  | I2C     | SDA1   | BIDI      | Local I2C data                               |
| 47  | I2C     | SCL1   | BIDI      | Local I2C clock                              |
| 53  | POWER   | GND    |           | Digital ground plane                         |

### WS2811B

1. External loop temperature status
2. External loop flow status
3. Internal loop temperature status
4. Internal loop flow status

### RS232 DE-9

0. Chassis earth
1. N/C
2. PC RX
3. PC TX
4. N/C
5. 0VDC
6. N/C
7. N/C
8. N/C
9. +5V

### Images

[Interactive BOM](https://agmlego.github.io/water-cooling-controller/pcie/ibom.html)

## Chiller Controller

| Pin | Type    | Signal | Direction | Purpose                                     |
| --- | ------- | ------ | --------- | ------------------------------------------- |
| 1   | POWER   | GND    |           | Digital ground                              |
| 2   | RS232   | RX     | INPUT     | RS232 receive                               |
| 3   | RS232   | TX     | OUTPUT    | RS232 transmit                              |
| 4   | 1-WIRE  | D2     | BIDI      | DS18B20 bus                                 |
| 10  | DIGITAL | D8     | OUTPUT    | Expansion valve relay                       |
| 11  | DIGITAL | D9     | OUTPUT    | Compressor relay                            |
| 12  | DIGITAL | D10    | OUTPUT    | [Fan PWM](#nf-a14-control)                  |
| 13  | DIGITAL | D11    | INPUT     | Bottom fan RPM sensor                       |
| 14  | DIGITAL | D12    | INPUT     | Top fan RPM sensor                          |
| 20  | DIGITAL | D13    | OUTPUT    | Status lights/buzzer relay                  |
| 21  | DIGITAL | D14    | OUTPUT    | Pump relay                                  |
| 22  | DIGITAL | D15    | INPUT     | Flow switch, active low                     |
| 23  | I2C     | SCL0   | BIDI      | Local I2C clock                             |
| 24  | I2C     | SDA0   | BIDI      | Local I2C data                              |
| 25  | DIGITAL | D18    | INPUT     | Encoder switch                              |
| 26  | DIGITAL | D19    | INPUT     | Encoder quadrature B                        |
| 27  | DIGITAL | D20    | INPUT     | Encoder quadrature A                        |
| 28  | ANALOG  | A7     | INPUT     | Filter check diff. pressure sensor          |
| 29  | ANALOG  | A8     | INPUT     | Reservoir eTape R<sub>ref</sub> 2000Ω       |
| 30  | ANALOG  | A9     | INPUT     | Reservoir eTape R<sub>sense</sub> 400-2000Ω |
| 31  | POWER   | 3V3    |           | 3.3V output                                 |
| 32  | POWER   | AGND   |           | Analog ground                               |
| 33  | POWER   | 5V     |           | 5V input from CAN                           |

### JST-XH Connectors

#### RS232
| Pin | Type  | Signal | Direction | Purpose           |
| --- | ----- | ------ | --------- | ----------------- |
| 1   | POWER | 5V     |           | 5V from PCIe card |
| 2   | POWER | GND    |           | Digital ground    |
| 3   | RS232 | RX     | INPUT     | RS232 receive     |
| 4   | RS232 | TX     | OUTPUT    | RS232 transmit    |

#### Flow
| Pin | Type    | Signal | Direction | Purpose        |
| --- | ------- | ------ | --------- | -------------- |
| 1   | DIGITAL | D15    | INPUT     | Flow switch    |
| 2   | POWER   | GND    |           | Digital ground |

#### DS18B20 One-Wire
| Pin | Type   | Signal | Direction | Purpose        |
| --- | ------ | ------ | --------- | -------------- |
| 1   | 1-WIRE | D2     | BIDI      | DS18B20 bus    |
| 2   | POWER  | GND    |           | Digital ground |
| 3   | POWER  | 3V3    |           | 3.3V output    |

#### Filter Diff. Pressure
| Pin | Type   | Signal | Direction | Purpose                            |
| --- | ------ | ------ | --------- | ---------------------------------- |
| 1   | POWER  | 3V3    |           | 3.3V output                        |
| 2   | POWER  | AGND   |           | Analog ground                      |
| 3   | ANALOG | A7     | INPUT     | Filter check diff. pressure sensor |

#### Reservoir Level eTape
| Pin | Type   | Signal | Direction | Purpose                     |
| --- | ------ | ------ | --------- | --------------------------- |
| 1   | ANALOG | A9     | INPUT     | R<sub>sense</sub> 400-2000Ω |
| 2   | ANALOG | A8     | INPUT     | R<sub>ref</sub> 2000Ω       |
| 3   | POWER  | AGND   |           | Analog ground               |
| 4   | POWER  | AGND   |           | Analog ground               |

#### Fans
| Pin | Type    | Signal | Direction | Purpose               |
| --- | ------- | ------ | --------- | --------------------- |
| 1   | DIGITAL | D12    | INPUT     | Top fan RPM sensor    |
| 2   | DIGITAL | D11    | INPUT     | Bottom fan RPM sensor |
| 3   | DIGITAL | D10    | OUTPUT    | Fan PWM               |

#### Dual-Relay Module
| Pin | Type    | Signal | Direction | Purpose                    |
| --- | ------- | ------ | --------- | -------------------------- |
| 1   | POWER   | GND    |           | Digital ground             |
| 2   | DIGITAL | D13    | OUTPUT    | Status lights/buzzer relay |
| 3   | DIGITAL | D14    | OUTPUT    | Pump relay                 |
| 4   | POWER   | 5V     |           | 5V input from CAN          |

#### SSRs
| Pin | Type    | Signal | Direction | Purpose               |
| --- | ------- | ------ | --------- | --------------------- |
| 1   | POWER   | GND    |           | Digital ground        |
| 2   | DIGITAL | D9     | OUTPUT    | Compressor relay      |
| 3   | POWER   | GND    |           | Digital ground        |
| 4   | DIGITAL | D8     | OUTPUT    | Expansion valve relay |

### NF-A14 Control
* PWM: 40μs period, 5Vpp
* 8.76% minimum kickon => 468RPM (64ms/15.6Hz on tach.)
* 100% => 3180RPM (9.4ms/106.4Hz on tach.)

### Images

[Interactive BOM](https://agmlego.github.io/water-cooling-controller/cw5200/ibom.html)

## KiCad design hardware/electrical/cw-5200_controller/cw-5200_controller.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF; C_1206_3216Metric
D1, D2, D3: GREEN; LED_1206_3216Metric
H3, H4, H5, H6: OLED; MountingHole_2.2mm_M2
H7: BME280; MountingHole_3.2mm_M3
J1: BME280 I2C; PinHeader_1x04_P2.54mm_Vertical
J2: Disp I2C; PinHeader_1x04_P2.54mm_Vertical
J3: Flo; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Res Level; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: Filter ΔP; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J6: Fans; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J7, J8: 1Wire; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: Relays; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J10: SSRs; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J11: RS232; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1, R2, R4: 220; R_1206_3216Metric
R3, R8, R9: 10k; R_1206_3216Metric
R5, R6: 1.2k; R_1206_3216Metric
R7: 4.7k; R_1206_3216Metric
SW1: EC11E18244A5; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: Teensy3.2; Teensy30_31_32_All_Pins
U2: MAX3232; TSSOP-16_4.4x5mm_P0.65mm

Connections:
1WIRE: J7.1, J8.1, R7.1, U1.4 (2)
+3.3V: C4.2, J1.1, J2.2, J5.1, J7.3, J8.3, R3.1, R4.1, R5.2, R6.1, R7.2, R8.1, R9.1, U1.31 (3.3V), U2.16 (VCC)
+5V: J9.4, J11.1, U1.33 (Vin)
/232RX: J11.3, U2.13 (R1IN)
/232TX: J11.4, U2.14 (T1OUT)
/TTLRX: R2.1, U1.2 (0_RX1_Touch), U2.12 (R1OUT)
/TTLTX: R1.1, U1.3 (1_TX1_Touch), U2.11 (T1IN)
BOTTOM_RPM: J6.2, R9.2, U1.13 (11_DOUT)
COMPRESSOR_RELAY: J10.2, U1.11 (9_RX2_CS_PWM)
ENC_A: SW1.A, U1.27 (20_A6_CS_PWM)
ENC_B: SW1.B, U1.26 (19_A5_SCL0_Touch)
ENC_SW: SW1.S2, U1.25 (18_A4_SDA0_Touch)
FAN_PWM: J6.3, U1.12 (10_TX2_CS_PWM)
FILTER_DP: J5.3, U1.28 (21_A7_RX1_CS_PWM)
FLOW_OK: D3.1 (K), J3.1, R3.2, U1.22 (15_A1_CS_Touch)
GND: C2.1, C3.2, C4.1, D1.1 (K), D2.1 (K), J1.2, J2.1, J3.2, J7.2, J8.2, J9.1, J10.1, J10.3, J11.2, SW1.C, SW1.MP, SW1.S1, U1.1 (GND), U2.15 (GND)
GNDA: J4.3, J4.4, J5.2, U1.32 (AGND)
I2C_SCL: J1.3, J2.3, U1.23 (16_A2_SCL0_Touch)
I2C_SDA: J1.4, J2.4, U1.24 (17_A3_SDA0_Touch)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R4.2
unnamed: C5.2, U2.1 (C1+)
unnamed: C5.1, U2.3 (C1-)
unnamed: C1.2, U2.4 (C2+)
unnamed: C1.1, U2.5 (C2-)
unnamed: C2.2, U2.2 (VS+)
unnamed: C3.1, U2.6 (VS-)
PUMP_RELAY: J9.3, U1.21 (14_A0_SCK)
RES_LEVEL: J4.1, R6.2, U1.30 (23_A9_Touch_PWM)
RES_TCOMP: J4.2, R5.1, U1.29 (22_A8_Touch_PWM)
STATUS_RELAY: J9.2, U1.20 (13_LED_SCK)
TOP_RPM: J6.1, R8.2, U1.14 (12_DIN)
VALVE_RELAY: J10.4, U1.10 (8_TX3_DIN)

Notes on the sheet:
PN-12110215TC-12
Rref
Rsense

Board: 2 copper layers, 85.0 x 46.0 mm, 36 parts (17 on the bottom side), 34 nets.

## KiCad design hardware/electrical/pcie_water_loop_controller/pcie_water_loop_controller.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; C_1206_3216Metric
D1, D2, D3, D4, D5, D6, D11: GREEN; LED_1206_3216Metric
D7: Ext T Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D8: Ext Flo Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D9: Int T Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D10: Int Flo Stat; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2: PCIe Bracket; MountingHole_3.2mm_M3_Pad_Via
H3, H4, H5, H6: OLED; MountingHole_2.2mm_M2
H7: BME280; MountingHole_3.2mm_M3
J1: Bus_PCI_Express_x1; BUS_PCIexpress_x1
J2: RS232; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
J3: Int T Hi; PinHeader_1x02_P2.54mm_Horizontal
J4: Int T Lo; PinHeader_1x02_P2.54mm_Horizontal
J5: Ext T Hi; PinHeader_1x02_P2.54mm_Horizontal
J6: Ext T Lo; PinHeader_1x02_P2.54mm_Horizontal
J7: BME280 I2C; PinHeader_1x04_P2.54mm_Vertical
J8: Disp I2C; PinHeader_1x04_P2.54mm_Vertical
J9: Int Flo; PinHeader_1x03_P2.54mm_Horizontal
J10: Ext Flo; PinHeader_1x03_P2.54mm_Horizontal
J11: SW In; PinHeader_1x02_P2.54mm_Horizontal
J12: SW Out; PinHeader_1x02_P2.54mm_Horizontal
J13: SMBus; PinHeader_1x04_P2.54mm_Vertical
R1, R7, R8, R17: 10k; R_1206_3216Metric
R2: 200; R_1206_3216Metric
R3, R4, R5, R6: 100k; R_1206_3216Metric
R9, R12, R13, R14, R15, R16: 220; R_1206_3216Metric
U1: Teensy3.2; Teensy30_31_32_All_Pins
U2: MAX3232; TSSOP-16_4.4x5mm_P0.65mm
U3: CNY17-3; SMDIP-6_W7.62mm
U4: Pololu U3V16F5; PinHeader_1x03_P2.54mm_Vertical
U5: 74125; TSSOP-14_4.4x5mm_P0.65mm

Connections:
#PERST: J1.A11 (~PERST), R16.1, U1.8 (6_PWM)
+3.3V: C6.2, J1.B10 (3.3Vaux), J7.1, J8.2, J9.1, J10.1, J13.1, R1.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R12.1, R13.1, R14.1, R17.1, U1.31 (3.3V), U1.42 (3.3V), U2.16 (VCC), U4.1 (Vin), U5.4, U5.5, U5.9, U5.10, U5.12, U5.13
+5V: C3.1, D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), J2.1, U4.3 (Vout), U5.14 (VCC)
/232RX: J2.2, U2.13 (R1IN)
/232TX: J2.3, U2.14 (T1OUT)
/#PRSNT: J1.A1 (~PRSNT1), J1.B17 (~PRSNT2)
/FP_PWR+: J12.1, U3.5
/FP_PWR-: J12.2, U3.4
/RGB_DOUT: U1.9 (7_RX3_DOUT), U5.2
/RGB_EN: R17.2, U1.7 (5_TX1_PWM), U5.1
/TTLRX: R9.1, U1.11 (9_RX2_CS_PWM), U2.12 (R1OUT)
/TTLTX: R15.1, U1.12 (10_TX2_CS_PWM), U2.11 (T1IN)
EXT_FLOW: D1.1 (K), J10.2, R7.2, U1.3 (1_TX1_Touch)
EXT_TEMP_HI: J5.1, R5.2, U1.21 (14_A0_SCK)
EXT_TEMP_LO: J6.1, R6.2, U1.22 (15_A1_CS_Touch)
Earth: H1.1, H2.1, J2.0 (PAD)
FP_PWR_IN: D4.1 (K), J11.1, R1.2, U1.30 (23_A9_Touch_PWM)
FP_PWR_OUT: R2.2, U1.29 (22_A8_Touch_PWM)
GND: C3.2, C4.1, C5.2, C6.1, D3.1 (K), D5.1 (K), D6.1 (K), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.1 (K), J1.A4 (GND), J1.A12 (GND), J1.A15 (GND), J1.A18 (GND), J1.B4 (GND), J1.B7 (GND), J1.B13 (GND), J1.B16 (GND), J1.B18 (GND), J2.5, J7.2, J8.1, J9.3, J10.3, J11.2, J13.2, U1.1 (GND), U1.53 (GND), U2.15 (GND), U3.2, U4.2 (GND), U5.7 (GND)
GNDA: J3.2, J4.2, J5.2, J6.2, U1.32 (AGND)
I2C_SCL: J7.3, J8.3, U1.47 (29_A18_SCL1)
I2C_SDA: J7.4, J8.4, U1.46 (30_A19_SDA1)
INT_FLOW: D2.1 (K), J9.2, R8.2, U1.2 (0_RX1_Touch)
INT_TEMP_HI: J3.1, R3.2, U1.23 (16_A2_SCL0_Touch)
INT_TEMP_LO: J4.1, R4.2, U1.24 (17_A3_SDA0_Touch)
unnamed: D1.2 (A), R12.2
unnamed: D2.2 (A), R13.2
unnamed: D3.2 (A), R2.1, U3.1
unnamed: D4.2 (A), R14.2
unnamed: D5.2 (A), R15.2
unnamed: D6.2 (A), R16.2
unnamed: D7.4 (DIN), U5.3
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D11.2 (A), R9.2
unnamed: C1.2, U2.1 (C1+)
unnamed: C1.1, U2.3 (C1-)
unnamed: C2.2, U2.4 (C2+)
unnamed: C2.1, U2.5 (C2-)
unnamed: C4.2, U2.2 (VS+)
unnamed: C5.1, U2.6 (VS-)
SMCLK: J1.B5 (SMCLK), J13.3, U1.26 (19_A5_SCL0_Touch)
SMDAT: J1.B6 (SMDAT), J13.4, U1.25 (18_A4_SDA0_Touch)

Board: 4 copper layers, 75.0 x 67.7 mm, 57 parts (18 on the bottom side), 44 nets.

## Code that names these connections

File firmware/CAN CW-5200 Controller/src/main.cpp (part):

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#define ONE_WIRE 2        // DS18B20 bus
#define VALVE_RLY 8       // OUTPUT valve
#define COMPRESSOR_RLY 9  // OUTPUT compressor
#define FAN_PWM 10        // OUTPUT fan PWM signal
#define BOTTOM_FAN_RPM 11 // INPUT Bottom fan tach
#define TOP_FAN_RPM 12    // INPUT Top fan tach
#define ALARMS_RLY 13     // OUTPUT alarms
#define PUMP_RLY 14       // OUTPUT pump
#define FLOW_SW 15        // INPUT PULLUP flow switch; low == OK
#define I2C_SDA 17        // Local I2C data
#define I2C_SCL 16        // Local I2C clock
#define ENCODER_SWITCH 18 // Encoder push switch
#define ENCODER_A 20      // Encoder quad channel A
#define ENCODER_B 19      // Encoder quad channel B
#define FILTER_P A7       // Analog input for differential pressure sensor
#define RES_LEVEL A9      // Analog input for eTape Rsense
#define RES_REF A8        // Analog input for eTape Rref

struct_readings readings;
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    attachInterrupt(BOTTOM_FAN_RPM, bottom_fan_pulse, FALLING);
    topRA.clear();
    bottomRA.clear();
    pinMode(FAN_PWM, OUTPUT);
    analogWriteFrequency(FAN_PWM, 25000);
    readings.chassis.fan.pwm = turnOffFans(FAN_PWM);

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
## Commit log

2024-03-02 ...random commit from laptop?
2024-03-03 Add initial CAN interfacing
2024-05-10 Converted to KiCad 8.0
2024-05-10 Further converted to KiCad 8.0
2024-05-10 Replaced CAN transciever with MAX3232
2024-05-10 Rearranging
2024-05-10 Initial RS232 control firmware
2024-05-10 Hopefully image rendering from https://github.com/linalinn/kicad-render?tab=readme-ov-file
2024-08-01 Changed PCIe card from CAN to RS232 via MAX3232
2024-08-01 Minor board fixes, updated PCIe README
2024-08-01 Moved to subdir
2024-08-02 Initial progress on CW-5200 local control board.
2024-08-02 Spelling dictionary
2024-08-02 Repinning to ease routing.
2024-08-02 ignore KiCAD lockfiles
2024-08-02 Corrected for OLED pinout.
2024-08-02 Finalized routing.
2024-08-02 fixed silk for OLED pinout
2024-08-13 Assembly BOMs.
2024-08-14 testing eTape calibration
2024-08-15 Retooling for EEPROM settings for limits.
2024-08-15 Added SerialTransfer library for telemetry
2024-08-15 Simple Python serial logger
2024-08-15 Added meter display
2024-08-16 Updates to reader and json plotter
2024-08-18 Added zero points for sensor calibrations
2024-08-18 Corrected RPM calls
2024-08-18 Removed old deps.
2024-08-18 Broke out to functions per measurement
2024-08-18 Added fan-specific files, retooled RPM measurement.
2024-08-18 Fixed signed/unsigned types.
2024-08-18 Made fan control more explicit, clear RPM averages when fans off.
2024-08-18 Moved constant
2024-08-18 Make USB serial explicit, added basic debug commands
2024-08-19 Maybe pcb images fixed?
2024-08-19 OK maybe actually do the thing?
2024-08-19 Turns out URL protocols are important who knew?
2024-08-19 Copy over KiCAD iboms to somewhere linkable
2024-08-19 try ibom action
2024-08-19 oops deps
2024-08-19 Removed local iboms; actions build for us now!
2024-08-19 Doing the fan tach the hard way because i missed the pin limitations of FreqMeasureMulti on the board...
2024-09-17 I2CDriver testing of ABP2 sensor
